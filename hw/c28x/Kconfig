## hw/c28x/Kconfig
```kconfig
config C28XEXP_MCU
    bool

config C28XEXAMPLE_BOARD
    bool
    select C28XEXP_MCU
```
